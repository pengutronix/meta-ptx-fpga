SRC_URI = "\
	git://github.com/strumtrar/litex-boards;protocol=https;branch=master \
"
SRCREV = "master"
PV = "0+git${SRCPV}"
