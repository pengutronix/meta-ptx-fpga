SRC_URI = "git://github.com/strumtrar/pythondata-cpu-vexriscv_smp;protocol=https;branch=master"
SRCREV = "0ede59d70aeeae593ee72c06a108243b250b17d4"
