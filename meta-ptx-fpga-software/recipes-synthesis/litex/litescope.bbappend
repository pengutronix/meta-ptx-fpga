LIC_FILES_CHKSUM = "file://LICENSE;md5=ab969670c1dff560d9f90d0b1846c269"

SRCREV = "2021.08"
PV = "2021.08"
