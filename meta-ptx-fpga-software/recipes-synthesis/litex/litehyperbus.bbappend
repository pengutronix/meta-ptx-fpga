LIC_FILES_CHKSUM = "file://LICENSE;md5=24f42c68cd88bddb4037957029d69817"

SRCREV = "2021.08"
PV = "2021.08"
