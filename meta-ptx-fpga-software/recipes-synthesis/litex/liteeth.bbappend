LIC_FILES_CHKSUM = "file://LICENSE;md5=70ab32fd17078e7007b69f144468f821"

SRCREV = "2021.08"
PV = "2021.08"
