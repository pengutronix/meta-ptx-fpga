LIC_FILES_CHKSUM = "file://LICENSE;md5=7472087497557b85f53fe7e0a1e26db6"

SRCREV = "2021.08"
PV = "2021.08"
