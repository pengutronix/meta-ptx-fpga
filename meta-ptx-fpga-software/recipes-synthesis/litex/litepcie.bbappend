LIC_FILES_CHKSUM = "file://LICENSE;md5=44143d0fdf0e8c41437a04b052be86c5"

SRCREV = "2021.08"
PV = "2021.08"
