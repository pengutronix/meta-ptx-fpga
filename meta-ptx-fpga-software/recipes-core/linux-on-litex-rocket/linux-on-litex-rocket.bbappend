FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-a-boot.json-file-to-load-binaries-in-Litex.patch"
