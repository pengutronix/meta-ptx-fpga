LIC_FILES_CHKSUM = "file://LICENSE;md5=d5fe6a63c47e2580771cc56883d2ed64"

SRCREV = "2022.12"
SRCPV = "2022.12"
