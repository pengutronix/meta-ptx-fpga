LIC_FILES_CHKSUM = "file://LICENSE;md5=c779474112984b3fbcfaba3dc8f3f3b4"

SRCREV = "2022.04"
SRCPV = "2022.04"
