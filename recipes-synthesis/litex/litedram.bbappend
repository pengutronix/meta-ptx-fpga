LIC_FILES_CHKSUM = "file://LICENSE;md5=f9889f63ba517bd604fde468a6b85bfd"

SRCREV = "2022.12"
SRCPV = "2022.12"
