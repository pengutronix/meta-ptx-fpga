LIC_FILES_CHKSUM = "file://LICENSE;md5=06961f9174ef2f11bff41b45f906eb5f"

SRCREV = "2022.12"
SRCPV = "2022.12"
