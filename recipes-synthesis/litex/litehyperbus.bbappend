LIC_FILES_CHKSUM = "file://LICENSE;md5=e40877df301ec6de075d51f4b7571d62"

SRCREV = "2022.04"
SRCPV = "2022.04"
